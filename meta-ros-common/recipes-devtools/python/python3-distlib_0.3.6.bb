SUMMARY = "Distribution utilities"
HOMEPAGE = "https://bitbucket.org/pypa/distlib"
LICENSE = "PSF"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f6a11430d5cd6e2cd3832ee94f22ddfc"

PYPI_PACKAGE = "distlib"

SRC_URI[md5sum] = "f60ba4e3f8e76c214d3d00b2227a16f7"
SRC_URI[sha256sum] = "14bad2d9b04d3a36127ac97f30b12a19268f211063d8f8ee4f47108896e11b46"

inherit pypi python_setuptools_build_meta

